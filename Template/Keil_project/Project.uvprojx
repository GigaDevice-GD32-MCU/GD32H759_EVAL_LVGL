# Keil uVision project Project.uvprojx, settings and files
target GD32H759_EVAL (6220000::V6.22::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.5.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H73X_75X,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include;..\..\Firmware\GD32H73x_75x_standard_peripheral\Include;..\GUI_APP\ui_lvgl;..\GUI_APP\ui_lvgl\assets;..\GUI_APP\ui_lvgl\demos;..\..\Utilities\bsp_drive;..\..\Utilities\lvgl\lvgl;..\..\Utilities\lvgl\lvgl\src;..\..\Utilities\lvgl\lvgl_port;..\..\Utilities\fatfs\fatfs;..\..\Utilities\fatfs\fatfs_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\Project.sct
  link misc: --diag_suppress=L6314
  group Application
    ../: main.c systick.c gd32h73x_75x_it.c
  group Peripherals
    ../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_adc.c gd32h73x_75x_can.c gd32h73x_75x_cau.c gd32h73x_75x_cau_aes.c gd32h73x_75x_cau_des.c gd32h73x_75x_cau_tdes.c gd32h73x_75x_cmp.c gd32h73x_75x_cpdm.c gd32h73x_75x_crc.c gd32h73x_75x_ctc.c gd32h73x_75x_dac.c gd32h73x_75x_dbg.c gd32h73x_75x_dci.c gd32h73x_75x_dma.c gd32h73x_75x_edout.c gd32h73x_75x_efuse.c gd32h73x_75x_enet.c gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_fac.c gd32h73x_75x_fmc.c gd32h73x_75x_fwdgt.c gd32h73x_75x_gpio.c gd32h73x_75x_hau.c gd32h73x_75x_hau_sha_md5.c gd32h73x_75x_hpdf.c gd32h73x_75x_hwsem.c gd32h73x_75x_i2c.c gd32h73x_75x_ipa.c gd32h73x_75x_lpdts.c gd32h73x_75x_mdio.c gd32h73x_75x_mdma.c gd32h73x_75x_misc.c gd32h73x_75x_ospi.c gd32h73x_75x_ospim.c gd32h73x_75x_pmu.c gd32h73x_75x_rameccmu.c gd32h73x_75x_rcu.c gd32h73x_75x_rspdif.c gd32h73x_75x_rtc.c gd32h73x_75x_rtdec.c gd32h73x_75x_sai.c gd32h73x_75x_sdio.c gd32h73x_75x_spi.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_tmu.c gd32h73x_75x_trigsel.c gd32h73x_75x_trng.c gd32h73x_75x_usart.c gd32h73x_75x_vref.c gd32h73x_75x_wwdgt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32H73x_75x/Source/: system_gd32h73x_75x.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32H73x_75x/Source/ARM/: startup_gd32h73x_75x.s
  group Doc
    ../../: README.md
  group bsp_drive
    ../../Utilities/bsp_drive/: bsp_adc.c bsp_i2c_touch.c bsp_mpu.c exmc_sdram.c lcd_font.c gd32h759i_eval.c gd32h759i_lcd_eval.c bsp_ts_gt911.c sdcard.c
  group ui_app
    ../GUI_APP/ui_lvgl/: fatfs_file_browse.c lv_about.c lv_demo_app.c lv_demo_picture.c lv_demo_qrcode.c lv_demo_setting.c lv_file_browse.c
    ../GUI_APP/ui_lvgl/demos/: lv_demos.c
    ../GUI_APP/ui_lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../GUI_APP/ui_lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../GUI_APP/ui_lvgl/demos/stress/: lv_demo_stress.c
    ../GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
  group ui_resource
    ../GUI_APP/ui_lvgl/assets/: arail_bold_10.c deguo_32.c german_arial_reg_10.c image_file_28.c image_folder_16.c image_folder_28.c image_folder_32.c img_about.c img_about_pressed.c img_background.c img_bmp.c img_file.c img_file_16.c img_file_32.c img_gd_logo.c img_home.c img_home_pressed.c img_mem.c img_music.c img_music_pressed.c img_open_bmp.c img_open_gif.c img_open_jpg.c img_open_png.c img_picture.c img_png.c img_qrcode.c img_setting.c img_sjpg.c img_speed.c img_speed_pressed.c img_temp.c img_widget.c img_widget_pressed.c japan_tanugo_reg_10.c lv_customer_font_SourceHanSerifSC_Regular_10.c lv_customer_font_SourceHanSerifSC_Regular_20.c lv_font_digital_20.c lv_font_digital_30.c lv_font_digital_35.c lv_font_digital_36.c lv_font_digital_60.c lv_font_msyhbd_100.c lv_font_msyh_100.c lv_font_msyh_50.c lv_font_msyh_90.c lv_font_tool_compat.c meiguo_32.c riben_32.c wave.c wuxinghongqi_32.c yahei_regular_10.c
    ../GUI_APP/ui_lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../GUI_APP/ui_lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/fs/: lv_fs_fatfs.c lv_fs.c
    ../../Utilities/lvgl/lvgl/src/: lv_init.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../Utilities/lvgl/lvgl/src/debugging/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../../Utilities/lvgl/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../Utilities/lvgl/lvgl/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../Utilities/lvgl/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../../Utilities/lvgl/lvgl/src/display/: lv_display.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../Utilities/lvgl/lvgl_port/gigadevice/ipa/: lv_draw_ipa.c lv_draw_ipa_fill.c lv_draw_ipa_img.c lv_draw_ipa_layer.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Utilities/lvgl/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../Utilities/lvgl/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Utilities/lvgl/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Utilities/lvgl/lvgl/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../Utilities/lvgl/lvgl/src/font/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../../Utilities/lvgl/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../Utilities/lvgl/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Utilities/lvgl/lvgl/src/layouts/: lv_layout.c
    ../../Utilities/lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/libs/barcode/: code128.c
    ../../Utilities/lvgl/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../Utilities/lvgl/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../../Utilities/lvgl/lvgl/src/libs/gif/: gif.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_data/: lv_gltf_model_loader.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../../Utilities/lvgl/lvgl/src/libs/lodepng/: lodepng.c
    ../../Utilities/lvgl/lvgl/src/libs/lz4/: lz4.c
    ../../Utilities/lvgl/lvgl/src/libs/nanovg/: nanovg.c
    ../../Utilities/lvgl/lvgl/src/libs/qrcode/: qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/libs/rle/: lv_rle.c
    ../../Utilities/lvgl/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/libs/tjpgd/: tjpgd.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_path.c vg_lite_stroke.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../../Utilities/lvgl/lvgl/src/logging/: lv_log.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Utilities/lvgl/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../../Utilities/lvgl/lvgl/src/stdlib/: lv_mem.c
    ../../Utilities/lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Utilities/lvgl/lvgl/src/themes/: lv_theme.c
    ../../Utilities/lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../Utilities/lvgl/lvgl/src/tick/: lv_tick.c
    ../../Utilities/lvgl/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Utilities/lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Utilities/lvgl/lvgl/src/widgets/arc/: lv_arc.c
    ../../Utilities/lvgl/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Utilities/lvgl/lvgl/src/widgets/bar/: lv_bar.c
    ../../Utilities/lvgl/lvgl/src/widgets/barcode/: lv_barcode.c
    ../../Utilities/lvgl/lvgl/src/widgets/button/: lv_button.c
    ../../Utilities/lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Utilities/lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Utilities/lvgl/lvgl/src/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/lvgl/lvgl/src/widgets/gif/: lv_gif.c
    ../../Utilities/lvgl/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../../Utilities/lvgl/lvgl/src/widgets/image/: lv_image.c
    ../../Utilities/lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Utilities/lvgl/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/widgets/label/: lv_label.c
    ../../Utilities/lvgl/lvgl/src/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/widgets/line/: lv_line.c
    ../../Utilities/lvgl/lvgl/src/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Utilities/lvgl/lvgl/src/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Utilities/lvgl/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../Utilities/lvgl/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../../Utilities/lvgl/lvgl/src/widgets/roller/: lv_roller.c
    ../../Utilities/lvgl/lvgl/src/widgets/scale/: lv_scale.c
    ../../Utilities/lvgl/lvgl/src/widgets/slider/: lv_slider.c
    ../../Utilities/lvgl/lvgl/src/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/widgets/switch/: lv_switch.c
    ../../Utilities/lvgl/lvgl/src/widgets/table/: lv_table.c
    ../../Utilities/lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/widgets/win/: lv_win.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c lv_port_indev.c
  group fatfs
    ../../Utilities/fatfs/fatfs/: ff.c ffsystem.c ffunicode.c
  group fatfs_port
    ../../Utilities/fatfs/fatfs_port/: diskio.c
software components: CMSIS:CORE 6.1.0
